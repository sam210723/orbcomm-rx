options:
  parameters:
    author: sam210723 (https://vksdr.com)
    description: Orbcomm Subscriber Transmitter downlink demodulator. Part of https://github.com/sam210723/orbcomm-rx
    generate_options: qt_gui
    id: orbcomm_demod
    output_language: python
    qt_qss_theme: E:\Google Drive\Documents\Radio\Satellites\Orbcomm\orbcomm-rx\demodulator\dark.qss
    title: Orbcomm STX Demodulator v1.0
  states: {}

blocks:
- name: af_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: psk_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: 4e3
    rate: '200e-3'
    reference: '500e-3'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '1000'
    rate: '0.1'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '3'
    audio_pass: '4000'
    audio_stop: '5000'
    chan_rate: samp_rate/4
    deviation: '8000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\Google Drive\Documents\Radio\Satellites\Orbcomm\orbcomm-rx\demodulator\symbols.bin
    type: byte
    vlen: packet_len
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1024'
    type: byte
    vlen: packet_len
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Program Files (x86)\SDRSharp 1653\IQ\2018_12_14\FM103 137.250 MHz Corrected.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: psk_obj
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    axislabels: 'False'
    gui_hint: 0,1
    legend: 'False'
    name: SDPSK Constellation
    size: '256'
    type: complex
    update_time: '0.01'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    axislabels: 'False'
    bw: samp_rate/8
    fc: '0'
    fftsize: '512'
    grid: 'True'
    gui_hint: 0,0
    label: ''
    label1: Raw IQ
    label2: RRC Filtered IQ
    legend: 'False'
    name: '"Raw + Filtered IQ"'
    nconnections: '2'
    showports: 'True'
    type: complex
    units: ''
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    axislabels: 'False'
    bw: samp_rate/4/8
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0
    label1: Raw IQ
    legend: 'False'
    name: '"PSK Order Check (4)"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-70'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    axislabels: 'False'
    bw: 125000/3
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,2
    label: ''
    label1: Raw IQ
    legend: 'False'
    name: '"FM Demodulated"'
    showports: 'True'
    type: float
    units: ''
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    axislabels: 'False'
    bw: samp_rate/4/8
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,0,1,2
    legend: 'False'
    name: '"Cyclostationary Analysis"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-45'
    ymin: '-80'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '2'
    decim: '4'
    gain: '1'
    ntaps: '512'
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rrc
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rrc
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}

connections:
- [analog_agc_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_agc_xx_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0_0, '0', analog_agc_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [rational_resampler_xxx_1, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_1_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '2']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '3']
- [virtual_source_0_0_0, '0', analog_fm_demod_cf_0, '0']
- [virtual_source_1, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
